# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC95F8617 SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./c/: main.c IO_Init.c SSI2_Init.c Timer_Init.c Uart_Init.c Tuya.c OLED.C
